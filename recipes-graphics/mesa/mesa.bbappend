# Copyright (c) 2025 Bartosz Szostak
# This software is released under the MIT License.
# See the LICENSE file for more details.

PACKAGECONFIG:append:rk3566 = " kmsro panfrost"

COMPATIBLE_MACHINE = "rockchip"
